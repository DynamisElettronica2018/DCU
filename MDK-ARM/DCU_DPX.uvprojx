# Keil uVision project DCU_DPX.uvprojx, settings and files
target DCU_DPX (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F767VITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x00200000-0x3FFFFF)  CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: DCU_DPX +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c include: ../Inc;                            ../Drivers/STM32F7xx_HAL_Driver/Inc;                            ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;                            ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;                            ../Drivers/CMSIS/Include;                    ../Middlewares/Third_Party/LwIP/src/include;                    ../Middlewares/Third_Party/LwIP/system;                    ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;                    ../Middlewares/Third_Party/LwIP/src/include/lwip;                    ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;                    ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;                    ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;                    ../Middlewares/Third_Party/LwIP/src/include/netif;                    ../Middlewares/Third_Party/LwIP/src/include/posix;                    ../Middlewares/Third_Party/LwIP/src/include/posix/sys;                    ../Middlewares/Third_Party/LwIP/system/arch;              ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;              ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;              ../Middlewares/Third_Party/FatFs/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/User
    ../Src/: user_ethernet_udp.c command_processing.c data.c system.c user_usb.c string_utility.c bno055.c user_sd.c main.c gpio.c adc.c can.c dma.c usbh_diskio.c fatfs.c i2c.c lwip.c ethernetif.c rtc.c tim.c usb_host.c usbh_conf.c usbh_platform.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Header Files
    ../Inc/: adc.h can.h can_id_defines.h command_processing.h data.h ethernetif.h fatfs.h ffconf.h gpio.h lwip.h lwipopts.h main.h rtc.h stm32f7xx_hal_conf.h stm32f7xx_it.h string_utility.h system.h telemetry_command.h tim.h usb_host.h usbh_conf.h usbh_diskio.h usbh_platform.h user_defines.h user_ethernet_udp.h user_sd.h user_usb.h bno055.h
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_eth.c stm32f7xx_hal_hcd.c stm32f7xx_ll_usb.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cortex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f7xx.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
software components: CMSIS:CORE 5.0.2
